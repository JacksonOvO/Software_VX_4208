# IAR project VX4204.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F302CB ST STM32F302CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; IO_CODE_TYPE=FR4024_CODE; IAP_IO_CODE_TYPE=IAP_FR4024_CODE; SCAN_HMODBUS_OPTIMIZE
  ICCARM.CCIncludePath2: ..\..\APP; ..\..\APP\Common; ..\..\APP\Common\inc; ..\..\APP\Common\opt; ..\..\APP\Init; ..\..\APP\Init\inc; ..\..\APP\Init\opt; ..\..\APP\Communication; ..\..\APP\Communication\inc; ..\..\APP\Communication\opt; ..\..\APP\ServiceHandling; ..\..\APP\ServiceHandling\inc; ..\..\APP\ServiceHandling\opt; ..\..\BSP; ..\..\BSP\CMSIS\Core\CM0; ..\..\Drivers; ..\..\Drivers\StdPeriph\inc; ..\..\Drivers\inc; ..\..\Drivers\opt; ..\..\Protocol; ..\..\Protocol\MBslave; ..\..\Protocol\MBslave\ascii; ..\..\Protocol\MBslave\include; ..\..\Protocol\MBslave\include\common; ..\..\Protocol\MBslave\include\internal; ..\..\Protocol\MBslave\port; ..\..\Protocol\MBslave\rtu; ..\..\RTTViewer\Config; ..\..\RTTViewer\RTT
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: VX4204.bin
  ILINK.IlinkOutputFile: VX4008.out
  ILINK.IlinkIcfFile: ..\..\BSP\ICF\stm32f30x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F303C8 ST STM32F303C8
  ICCARM.CCIncludePath2: ..\..\APP; ..\..\APP\Common; ..\..\APP\Common\inc; ..\..\APP\Common\opt; ..\..\APP\Init; ..\..\APP\Init\inc; ..\..\APP\Init\opt; ..\..\APP\Communication; ..\..\APP\Communication\inc; ..\..\APP\Communication\opt; ..\..\APP\ServiceHandling; ..\..\APP\ServiceHandling\inc; ..\..\APP\ServiceHandling\opt; ..\..\BSP; ..\..\BSP\CMSIS\Core\CM0; ..\..\Drivers; ..\..\Drivers\StdPeriph\inc; ..\..\Drivers\inc; ..\..\Drivers\opt; ..\..\Protocol; ..\..\Protocol\MBslave; ..\..\Protocol\MBslave\ascii; ..\..\Protocol\MBslave\include; ..\..\Protocol\MBslave\include\common; ..\..\Protocol\MBslave\include\internal; ..\..\Protocol\MBslave\port; ..\..\Protocol\MBslave\rtu
  OBJCOPY.OOCOutputFile: FR4024.bin
  ILINK.IlinkOutputFile: FR4024.out
  ILINK.IlinkIcfFile: D:\workspace\projects\RELEASE\4XC8\40X8 update\VX4008\FR4028 -2\BSP\ICF\stm32f30x_flash.icf
  group APP
    ../../APP/: main.c
  group APP/Common
    ../../APP/Common/src/: common.c diagnose.c warn.c watchdog.c
  group APP/Communication
    ../../APP/Communication/src/: MbCommunication.c
  group APP/Init
    ../../APP/Init/src/: IoInit.c
  group APP/ServiceHandling
    ../../APP/ServiceHandling/src/: HModbusOptimize.c Iocontrol.c MasterCommunication.c
  group BSP/CMSIS/Core/CM0
    ../../BSP/CMSIS/Core/CM0/: system_stm32f30x.c
  group BSP/CMSIS/Core/CM0/startup
    ../../BSP/CMSIS/Core/CM0/startup/: startup_stm32f30x.s
  group Drivers
    ../../Drivers/src/: STM32DAC8555Driver.c STM32F0IAPDriver.c STM32F0SPIDrive.c STM32F0usart.c stm32f0xx_port_debug.c STM32GPIODriver.c
  group Drivers/StdPeriph
    ../../Drivers/StdPeriph/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group Protocol/MBslave
    ../../Protocol/MBslave/: mbs.c
  group Protocol/MBslave/common
    ../../Protocol/MBslave/common/: mbutils.c
  group Protocol/MBslave/functions
    ../../Protocol/MBslave/functions/: mbsfunccoils.c mbsfuncdiag.c mbsfuncdisc.c mbsfuncfiles.c mbsfuncholding.c mbsfuncinput.c mbsslaveid.c
  group Protocol/MBslave/port
    ../../Protocol/MBslave/port/: mbportevent.c mbportother.c mbportserial.c mbporttimer.c
  group Protocol/MBslave/rtu
    ../../Protocol/MBslave/rtu/: mbscrc.c mbsrtu.c
  group RTTViewer/Config
    ../../RTTViewer/Config/: SEGGER_RTT_Conf.h
  group RTTViewer/RTT
    ../../RTTViewer/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group RTTViewer/Syscalls
    ../../RTTViewer/Syscalls/: SEGGER_RTT_Syscalls_IAR.c
